options:
  parameters:
    generate_options: qt_gui
    id: FM
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: Noise
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '100'
    value: '0'
    widget: slider
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(44.1e3)
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '1'
    quad_rate: samp_rate
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: samp_rate
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: samp_rate
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    samp_rate: '44100'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '5'
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: D:\ECE\5th Semester\DSP lab\Journey(chosic.com).wav
    repeat: 'True'
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: Noise
    seed: '0'
    taps: '1.0'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 96e6
    fftsize: '1024'
    name: '"After Channel Model"'
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: 98e6
    fftsize: '1024'
    name: '"Before Channel Model"'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '100'
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '100'
    interp: '1'
    type: ccc
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [audio_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_add_xx_0, '0', analog_wfm_tx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_wavfile_source_0, '0', blocks_add_xx_0, '0']
- [channels_channel_model_0, '0', rational_resampler_xxx_0_0, '0']
- [rational_resampler_xxx_0, '0', channels_channel_model_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0_0, '0', analog_wfm_rcv_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
